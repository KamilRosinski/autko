File: Power_supply.kicad_sch (KiCad schematic)
At the start: 31 parts

Commit message: Annotate schematics
Parts:
- gave numbers to parts that had none: 31
